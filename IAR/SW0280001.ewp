# IAR project SW0280001.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K144 NXP S32K144
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_S32K144HFT0VLLT; DEV_ERROR_DETECT
  ICCARM.CCIncludePath2: ..\Generated_Code; ..\MySDK\platform\devices; ..\MySDK\platform\devices\common; ..\MySDK\platform\devices\S32K144\include; ..\MySDK\platform\devices\S32K144\startup; ..\MySDK\platform\drivers\inc; ..\MySDK\platform\drivers\src\adc; ..\MySDK\platform\drivers\src\clock\S32K1xx; ..\MySDK\platform\drivers\src\edma; ..\MySDK\platform\drivers\src\flexcan; ..\MySDK\platform\drivers\src\flexio; ..\MySDK\platform\drivers\src\lpit; ..\MySDK\platform\drivers\src\lpspi; ..\MySDK\platform\drivers\src\pdb; ..\MySDK\platform\drivers\src\pins; ..\MySDK\platform\drivers\src\trgmux; ..\MySDK\platform\pal\adc\inc; ..\MySDK\platform\pal\adc\src; ..\MySDK\platform\pal\can\inc; ..\MySDK\rtos\osif; ..\Sources\App; ..\Sources\Bsp; ..\Sources\S32K
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SW0280001.hex
  ILINK.IlinkOutputFile: SW0280001.out
  ILINK.IlinkIcfFile: linker_Files\S32K144_64_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Generated_Code
    ../Generated_Code/: ADC_0.c ADC_0.h ADC_1.c ADC_1.h adc_pal_cfg.h canCom1.c canCom1.h clockMan1.c clockMan1.h Cpu.c Cpu.h crc1.c crc1.h dmaController1.c dmaController1.h flexio_M4.c flexio_M4.h LPSPI_MLX_1.c LPSPI_MLX_1.h LPSPI_MLX_2.c LPSPI_MLX_2.h LPSPI_TLF.c LPSPI_TLF.h MyFlash.c MyFlash.h MySysTmr.c MySysTmr.h pin_mux.c pin_mux.h
  group MyCode/Sources
    ../Sources/: boot.c boot.h main.c
  group MyCode/Sources/App
    ../Sources/App/: application.c application.h digital.c digital.h djwConfig.h error.c error.h flash.c flash.h isobus.c isobus.h memdata.c memdata.h mlx.c mlx.h pool.c pool.h roller.c roller.h saej1939.c saej1939.h supply.c supply.h
  group MyCode/Sources/Bsp
    ../Sources/Bsp/: AppTranslate.c AppTranslate.h S32K_Driver.c S32K_Driver.h S32K_ObjectConfig.c S32K_ObjectConfig.h TLF_Spi.c TLF_Spi.h
  group MyCode/Sources/S32K
    ../Sources/S32K/: queue.c queue.h S32K_Adc.c S32K_Adc.h S32K_CanDma.c S32K_CanDma.h S32K_Flash.c S32K_Flash.h S32K_flexSpi.c S32K_flexSpi.h S32K_LpSpi.c S32K_LpSpi.h S32K_SysPin.c S32K_SysPin.h S32K_Timer.c S32K_Timer.h wtypes.h
  group MySDK
    ../MySDK/platform/drivers/src/adc/: adc_driver.c adc_hw_access.h
    ../MySDK/platform/drivers/inc/: adc_driver.h clock_manager.h crc_driver.h edma_driver.h flash_driver.h flexcan_driver.h flexio.h flexio_spi_driver.h interrupt_manager.h lpit_driver.h lpspi_master_driver.h lpspi_shared_function.h lpspi_slave_driver.h pdb_driver.h pins_driver.h trgmux_driver.h
    ../MySDK/platform/pal/adc/src/: adc_irq.c adc_irq.h adc_pal.c
    ../MySDK/platform/pal/adc/inc/: adc_pal.h adc_pal_mapping.h
    ../MySDK/platform/devices/: callbacks.h devassert.h device_registers.h startup.c startup.h status.h
    ../MySDK/platform/drivers/src/clock/: clock_manager.c
    ../MySDK/platform/drivers/src/clock/S32K1xx/: clock_S32K1xx.c clock_S32K1xx.h pcc_hw_access.h pmc_hw_access.h scg_hw_access.h sim_hw_access.h smc_hw_access.h
    ../MySDK/platform/drivers/src/crc/: crc_driver.c crc_hw_access.c crc_hw_access.h
    ../MySDK/platform/drivers/src/edma/: edma_driver.c edma_hw_access.c edma_hw_access.h edma_irq.c edma_irq.h
    ../MySDK/platform/drivers/src/flash/: flash_driver.c
    ../MySDK/platform/drivers/src/flexcan/: flexcan_driver.c flexcan_hw_access.c flexcan_hw_access.h flexcan_irq.c flexcan_irq.h
    ../MySDK/platform/drivers/src/flexio/: flexio_common.c flexio_common.h flexio_hw_access.h flexio_spi_driver.c
    ../MySDK/platform/drivers/src/interrupt/: interrupt_manager.c
    ../MySDK/platform/drivers/src/lpit/: lpit_driver.c lpit_hw_access.h
    ../MySDK/platform/drivers/src/lpspi/: lpspi_hw_access.c lpspi_hw_access.h lpspi_irq.c lpspi_master_driver.c lpspi_shared_function.c lpspi_slave_driver.c
    ../MySDK/rtos/osif/: osif.h osif_baremetal.c
    ../MySDK/platform/drivers/src/pdb/: pdb_driver.c pdb_hw_access.c pdb_hw_access.h
    ../MySDK/platform/drivers/src/pins/: pins_driver.c pins_gpio_hw_access.h pins_port_hw_access.c pins_port_hw_access.h
    ../MySDK/platform/devices/common/: s32_core_cm4.h
    ../MySDK/platform/devices/S32K144/include/: S32K144.h S32K144_features.h
    ../MySDK/platform/devices/S32K144/startup/: system_S32K144.c system_S32K144.h
    ../MySDK/platform/drivers/src/trgmux/: trgmux_driver.c trgmux_hw_access.c trgmux_hw_access.h
  group Project_Settings/Linker_Files
    linker_Files/: S32K144_64_flash.icf
    Linker_Files/: S32K144_64_ram.icf startup_S32K144.s
